# Keil uVision project led_flow.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: led_flow +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx
  c include: .\SYSTEM\usart;.\SYSTEM\delay;.\SYSTEM\sys;.\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\HARDWARE;.\Libraries\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group User
    ./User/: main.c
  group Hardware
    ./HARDWARE/LED/: led.c led.h
  group System
    ./SYSTEM/sys/: sys.c sys.h
    ./SYSTEM/delay/: delay.c delay.h
    ./SYSTEM/usart/: usart.c usart.h
